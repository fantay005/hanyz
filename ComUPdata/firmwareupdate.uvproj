# Keil uVision project firmwareupdate.uvproj, settings and files
target LED (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: firmwareupdate +hex
  c flags: Optim=1 OneElfS=1
  c define: inline=__inline __DEBUG__=1 LED_DEVICE=1
  c include: .;.\fwlib;.\hardware;.\m35;.\lib;.\update
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group hardware
    ./hardware/: gpioconfigure.c hardware.h nvicconfigure.c rccconfigure.c startup_stm32f10x_hd.s stm32f10x_conf.h usartconfigure.c usartio.c systickconfigure.c iwdgconfigure.c inside_flash.c
  group update
    ./update/: main.c firmware.c libupdater.c
  group fwlib
    ./fwlib/: cortexm3_macro.h cortexm3_macro.s fsmc_nor.c fsmc_nor.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_lib.c stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.c stm32f10x_nvic.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_type.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_systick.h stm32f10x_systick.c stm32f10x_iwdg.c
  group m35
    ./m35/: m35.c m35.h m35at.c m35at.h m35fs.h m35ftp.c m35ftp.h m35sendsms.c m35sendsms.h
target AUDIO (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: firmwareupdate +hex
  c define: inline=__inline __DEBUG__=1 AUDIO_DEVICE=1
  c include: .;.\fwlib;.\hardware;.\m35;.\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target AUDIO_V2 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: firmwareupdate +hex
  c define: inline=__inline __DEBUG__=1 AUDIO_DEVICE_V2=1
  c include: .;.\fwlib;.\hardware;.\m35;.\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target AUDIO_V3 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: firmwareupdate +hex
  c define: inline=__inline __DEBUG__=1    __SPEAKER_V3__=1
  c include: .;.\fwlib;.\hardware;.\m35;.\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
